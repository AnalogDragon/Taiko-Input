# Keil uVision project CH554.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: TK_NS_PC_V20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public
  group Source Group 1
    ./: CompatibilityHID.C GPIO.c
    ./Public/: Debug.C
